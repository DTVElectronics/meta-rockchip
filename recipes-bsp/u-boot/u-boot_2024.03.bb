require u-boot-common.inc
require poky/meta/recipes-bsp/u-boot/u-boot.inc

DEPENDS += "bc-native dtc-native python3-pyelftools-native"

