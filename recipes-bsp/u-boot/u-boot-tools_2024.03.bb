require u-boot-common.inc
require poky/meta/recipes-bsp/u-boot/u-boot-tools.inc
